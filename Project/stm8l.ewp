# IAR project stm8l.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L101F3P STM8L101F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: EWSTM8_IAR
  ICCSTM8.CCIncludePath2: D:\tm88\STM8\main_program\Libraries\inc; D:\tm88\STM8\main_program\User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8l.hex
  ILINK.IlinkOutputFile: stm8l.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Libraries
    ../Libraries/src/: stm8l10x_clk.c stm8l10x_exti.c stm8l10x_gpio.c stm8l10x_tim2.c stm8l10x_usart.c
  group User
    ../User/: main.c stm8l10x_conf.h stm8l10x_it.c stm8l10x_it.h
